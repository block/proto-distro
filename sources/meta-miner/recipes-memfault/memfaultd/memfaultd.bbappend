FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PACKAGECONFIG := "swupdate collectd coredump logging"
