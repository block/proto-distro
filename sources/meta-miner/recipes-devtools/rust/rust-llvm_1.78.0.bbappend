# WORKAROUND: Allow network access for the compile step, to download the llvmbox file
do_compile[network] = "yes"
