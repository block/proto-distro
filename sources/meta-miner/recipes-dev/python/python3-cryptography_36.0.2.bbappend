BB_STRICT_CHECKSUM = "0"